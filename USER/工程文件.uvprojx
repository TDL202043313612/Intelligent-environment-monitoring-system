# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart1.c timer4.c stm32f10x_it.c usart2.c led.c wifi.c mqtt.c timer3.c timer1.c key.c timer2.c dht11.c oled.c
    ./: sys.h adc.c adc.h
    C:/Users/A/OneDrive/桌面/15-ESP8266 阿里云IoT Studio开发 Web控制 温湿度上传/HARDWARE/scr/: timer5.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
